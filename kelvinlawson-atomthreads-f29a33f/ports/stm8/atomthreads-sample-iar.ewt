<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>fatFs</name>
    <file>
      <name>$PROJ_DIR$\..\..\fatFS\diskio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\fatFS\diskio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\fatFS\ff.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\fatFS\ff.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\fatFS\ffconf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\fatFS\integer.h</name>
    </file>
  </group>
  <group>
    <name>kernel</name>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atomkernel.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atommutex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atommutex.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atomqueue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atomqueue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atomsem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atomsem.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atomtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kernel\atomtimer.h</name>
    </file>
    <configuration>
      <name>Debug</name>
    </configuration>
    <configuration>
      <name>Release</name>
    </configuration>
  </group>
  <group>
    <name>stm8</name>
    <file>
      <name>$PROJ_DIR$\atomport-asm-iar.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\atomport-private.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\atomport-tests.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\atomport.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\atomport.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\tests-main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\uart.h</name>
    </file>
    <configuration>
      <name>Debug</name>
    </configuration>
    <configuration>
      <name>Release</name>
    </configuration>
  </group>
  <group>
    <name>stm8s-periphs</name>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_clk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_itc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_tim1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_type.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_uart2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8s-periphs\stm8s_uart2.h</name>
    </file>
    <configuration>
      <name>Debug</name>
    </configuration>
    <configuration>
      <name>Release</name>
    </configuration>
  </group>
  <group>
    <name>tests</name>
    <file>
      <name>$PROJ_DIR$\..\..\tests\atomtests.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\tests\sem1.c</name>
    </file>
    <configuration>
      <name>Debug</name>
    </configuration>
    <configuration>
      <name>Release</name>
    </configuration>
  </group>
</project>


