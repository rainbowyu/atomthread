<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Backup of atomthreads-sample-iar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comAtomthreads.ewp</path>
  </project>
  <batchBuild/>
</workspace>


