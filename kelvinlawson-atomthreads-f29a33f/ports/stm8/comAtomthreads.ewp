# IAR project comAtomthreads.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: ATOM_STACK_CHECKING; STM8S207
  ICCSTM8.CCIncludePath2: stm8s-periphs; $PROJ_DIR$; threads; ..\..\kernel; ..\..\fatFS; ..\..\tests; ..\..\hardwaredriver; ..\..\hardwaredriver\stm8speriphs; ..\..\spifFs\test; ..\..\spifFs; ..\..\u8glib\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: comAtomthreads.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group fatFs
    ../../fatFS/: diskio.c diskio.h ff.c ff.h ffconf.h filecommon.c filecommon.h integer.h
  group hardWareDriver
    ../../hardwaredriver/: spiflash.c spiflash.h
  group hardWareDriver/stm8speriphs
    ../../hardwaredriver/stm8speriphs/: spidriver.c spidriver.h
  group kernal
    ../../kernel/: atom.h atomkernel.c atommutex.c atommutex.h atomport-template.h atomqueue.c atomqueue.h atomsem.c atomsem.h atomtimer.c atomtimer.h
  group spifFs
    ../../spifFs/: spiffs.h spiffs_cache.c spiffs_check.c spiffs_config.h spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c spiffs_nucleus.h
  group stm8
    ./: atomport-asm-iar.s atomport-private.h atomport.c atomport.h mainthread.c spifFs-main.c tests-main.c uart.c
  group stm8lib
    stm8s-periphs/: stm8s.h stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_spi.c stm8s_tim1.c stm8s_uart3.c
  group threads
    threads/: displaythread.c filethread.c uartrxthread.c
  group u8gLib
    ../../../../u8glib/src/: u8g.h u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_i2c.c u8g_com_io.c u8g_com_null.c u8g_cursor.c u8g_delay.c u8g_dev_a2_micro_printer.c u8g_dev_flipdisc_2x7.c u8g_dev_gprof.c u8g_dev_null.c u8g_dev_uc1701_mini12864.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pbxh16.c u8g_pbxh24.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u16toa.c u8g_u8toa.c u8g_virtual_screen.c
    ../../u8glib/src/: u8g_stm8s.c
  group u8gLibexc
    ../../../../u8glib/src/: chessengine.c u8g_dev_ht1632.c u8g_dev_ili9325d_320x240.c u8g_dev_ks0108_128x64.c u8g_dev_lc7981_160x80.c u8g_dev_lc7981_240x128.c u8g_dev_lc7981_240x64.c u8g_dev_lc7981_320x64.c u8g_dev_pcd8544_84x48.c u8g_dev_pcf8812_96x65.c u8g_dev_sbn1661_122x32.c u8g_dev_ssd1306_128x32.c u8g_dev_ssd1306_128x64.c u8g_dev_ssd1309_128x64.c u8g_dev_ssd1322_nhd31oled_bw.c u8g_dev_ssd1322_nhd31oled_gr.c u8g_dev_ssd1325_nhd27oled_bw.c u8g_dev_ssd1325_nhd27oled_bw_new.c u8g_dev_ssd1325_nhd27oled_gr.c u8g_dev_ssd1325_nhd27oled_gr_new.c u8g_dev_ssd1327_96x96_gr.c u8g_dev_ssd1351_128x128.c u8g_dev_st7565_64128n.c u8g_dev_st7565_dogm128.c u8g_dev_st7565_dogm132.c u8g_dev_st7565_lm6059.c u8g_dev_st7565_lm6063.c u8g_dev_st7565_nhd_c12832.c u8g_dev_st7565_nhd_c12864.c u8g_dev_st7687_c144mvgd.c u8g_dev_st7920_128x64.c u8g_dev_st7920_192x32.c u8g_dev_st7920_202x32.c u8g_dev_t6963_128x64.c u8g_dev_t6963_240x128.c u8g_dev_t6963_240x64.c u8g_dev_tls8204_84x48.c u8g_dev_uc1601_c128032.c u8g_dev_uc1610_dogxl160.c u8g_dev_uc1701_dogs102.c
